## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="jialongfei"
CONFIG_EXAMPLE_WIFI_PASSWORD="19981230"
CONFIG_LV_USE_USER_DATA=y
CONFIG_LV_COLOR_16_SWAP=y
CONFIG_LV_COLOR_DEPTH_16=y
```
